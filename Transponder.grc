options:
  parameters:
    author: root
    generate_options: no_gui
    id: Transponder
    output_language: python
    title: Transponder
  states: {}

blocks:
- name: rx_freq
  id: variable
  parameters:
    value: '1700000000'
  states: {}
- name: rx_ip
  id: variable
  parameters:
    value: '''usb:1.7.5'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '1750000000'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: tx_freq
    samplerate: samp_rate
    type: fc32
    uri: rx_ip
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: rx_freq
    gain1: '''manual'''
    manual_gain1: '70'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: rx_ip
  states: {}

connections:
- [iio_pluto_source_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
